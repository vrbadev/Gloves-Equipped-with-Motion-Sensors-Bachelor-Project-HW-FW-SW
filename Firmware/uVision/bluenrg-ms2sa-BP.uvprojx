# Keil uVision project bluenrg-ms2sa-BP.uvprojx, settings and files
target BlueNRG-M2SA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: BlueNRG-2 STMicroelectronics
  pack: Keil.STBlueNRG-2_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bluenrg-ms2sa-BP +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib_stack\inc;.\lib_layers\layers_inc;.\lib_bluenrg1_peripherals\inc;.\lib_crypto\inc;.\lib_hal\inc;.\lib_bluenrg1_startup\Include
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\BlueNRG2.sct
  group main
    ./: BlueNRG1_it.c main.c ble_app.c adc.c delay.c i2c.c uart.c sensors.c
  group lib_bluenrg1_peripherals
    ./lib_bluenrg1_peripherals/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group lib_bluenrg1_startup
    ./lib_bluenrg1_startup/Source/: system_bluenrg1.c
  group lib_hal
    ./lib_hal/src/: clock.c context_switch.s miscutil.c osal.c sleep.c
  group lib_stack
    ./lib_stack/src/: stack_user_cfg.c
    ./lib_stack/library/: libbluenrg1_stack.a
  group lib_crypto
    ./lib_crypto/: libcrypto.a
  group lib_sensors
    ./lib_sensors/src/: LSM6DSL_ACC_GYRO_Driver.c LSM6DSLSensor.c lis2mdl_reg.c LIS2MDLSensor.c LPS22HB_Driver.c LPS22HBSensor.c
  group inc
    ./inc/: BlueNRG1_it.h ble_app.h adc.h delay.h i2c.h uart.h ble_stack.h sensors.h
software components: CMSIS:CORE 5.3.0
